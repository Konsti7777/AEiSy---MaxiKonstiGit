# Keil uVision project STM32G474.uvprojx, settings and files
target AEiSy_Px (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EBSy_Px
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\System;.\CMSIS;.\System
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Sources
    ./: main.c delay.s delay.h Event.c Event.h LED.c LED.h Display.c Display.h Sonic.c Sonic.h
  group System
    ./System/: stm32g4xx.h STM32G4xx_REG_ASM.inc stm32g474xx.h system_stm32g4xx.c startup_stm32g474xx.s
